# IAR project LPC-DfuSe-Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LPC-DfuSe-Bootloader.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __LPC177X_8X__; USB_DEVICE_ONLY=1
  ICCARM.CCIncludePath2: ; src\; src\lpc1788\Drivers\include\; src\lpc1788\Core\DeviceSupport\NXP\LPC177x_8x\; src\lpc1788\Core\CoreSupport\; src\uCOS-III\; src\uCOS-III\uC-CPU\ARM-Cortex-M3\; src\uCOS-III\uC-CPU\; src\uCOS-III\uC-LIB\; src\uCOS-III\Source\; src\uCOS-III\Ports\ARM-Cortex-M3\IAR\; src\src\ethernet_messaging\lwip-1.4.0\src\include\; src\src\ethernet_messaging\lwip-1.4.0\lwip_port\; src\src\ethernet_messaging\lwip-1.4.0\lwip_port\arch\; src\src\ethernet_messaging\lwip-1.4.0\src\include\ipv4\; src\src\ethernet_messaging\lwip-1.4.0\src\include\ipv6\; src\src\usb_task\nxpUSBLib\; src\src\usb_task\nxpUSBLib\Drivers\USB\; src\src\usb_task\nxpUSBLib\Common\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: LPC-DfuSe-Bootloader.hex
  ILINK.IlinkIcfFile: D:\projects\arm\delta\LPC-DfuSe-Bootloader\src\lpc1788\sram_bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    src/: app_cfg.h app_vect.c cpu_cfg.h main.c main.h os_cfg.h os_cfg_app.h
  group bsp
    src/bsp/: bsp.c bsp.h bsp_int.c bsp_int.h
  group debug
    src/debug/: debug.c debug.h
  group iap
    src/iap/: iap.c iap.h
  group lpc1788
    src/lpc1788/: sram_bootloader.icf
  group lpc1788/Core
    src/lpc1788/Core/CoreSupport/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
    src/lpc1788/Core/DeviceSupport/NXP/LPC177x_8x/: LPC177x_8x.h system_LPC177x_8x.c system_LPC177x_8x.h
  group lpc1788/Drivers/include
    src/lpc1788/Drivers/include/: debug_frmwrk.h lpc177x_8x_adc.h lpc177x_8x_can.h lpc177x_8x_clkpwr.h lpc177x_8x_crc.h lpc177x_8x_dac.h lpc177x_8x_eeprom.h lpc177x_8x_emac.h lpc177x_8x_emc.h lpc177x_8x_exti.h lpc177x_8x_gpdma.h lpc177x_8x_gpio.h lpc177x_8x_i2c.h lpc177x_8x_i2s.h lpc177x_8x_mci.h lpc177x_8x_mcpwm.h lpc177x_8x_nvic.h lpc177x_8x_pinsel.h lpc177x_8x_pwm.h lpc177x_8x_qei.h lpc177x_8x_rtc.h lpc177x_8x_ssp.h lpc177x_8x_systick.h lpc177x_8x_timer.h lpc177x_8x_uart.h lpc177x_8x_wwdt.h lpc_types.h
  group lpc1788/Drivers/source
    src/lpc1788/Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_eeprom.c lpc177x_8x_gpio.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_wwdt.c
  group src/usb_task
    src/src/usb_task/: Descriptors.c Descriptors.h dfu.h usb_task.c usb_task.h
  group src/usb_task/nxpUsbLib
    src/src/usb_task/nxpUSBLib/: nxpUSBlibConfig.h Version.h
  group src/usb_task/nxpUsbLib/Common
    src/src/usb_task/nxpUSBLib/Common/: Architectures.h ArchitectureSpecific.h Attributes.h BoardTypes.h Common.h CompilerSpecific.h Endianness.h
  group src/usb_task/nxpUsbLib/Drivers
    src/src/usb_task/nxpUSBLib/Drivers/USB/: USB.h
  group src/usb_task/nxpUsbLib/Drivers/Class
    src/src/usb_task/nxpUSBLib/Drivers/USB/Class/: AudioClass.h CDCClass.h HIDClass.h MassStorageClass.h MIDIClass.h PrinterClass.h RNDISClass.h StillImageClass.h
  group src/usb_task/nxpUsbLib/Drivers/Class/Common
    src/src/usb_task/nxpUSBLib/Drivers/USB/Class/Common/: AudioClassCommon.h CDCClassCommon.h HIDClassCommon.h HIDParser.c HIDParser.h HIDReportData.h MassStorageClassCommon.h MIDIClassCommon.h PrinterClassCommon.h RNDISClassCommon.h StillImageClassCommon.h
  group src/usb_task/nxpUsbLib/Drivers/Class/Device
    src/src/usb_task/nxpUSBLib/Drivers/USB/Class/Device/: AudioClassDevice.c AudioClassDevice.h CDCClassDevice.c CDCClassDevice.h HIDClassDevice.c HIDClassDevice.h MassStorageClassDevice.c MassStorageClassDevice.h MIDIClassDevice.c MIDIClassDevice.h RNDISClassDevice.c RNDISClassDevice.h
  group src/usb_task/nxpUsbLib/Drivers/Core
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/: ConfigDescriptor.c ConfigDescriptor.h Device.h DeviceStandardReq.c DeviceStandardReq.h Endpoint.h EndpointStream.h Events.c Events.h Host.h HostStandardReq.c HostStandardReq.h OTG.h Pipe.h PipeStream.h StdDescriptors.h StdRequestType.h USBController.h USBInterrupt.h USBMemory.c USBMemory.h USBMode.h USBTask.c USBTask.h
  group src/usb_task/nxpUsbLib/Drivers/Core/LPC
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/LPC/: Device_LPC.c Device_LPC.h Endpoint_LPC.c Endpoint_LPC.h EndpointStream_LPC.c EndpointStream_LPC.h Host_LPC.c Host_LPC.h Pipe_LPC.c Pipe_LPC.h PipeStream_LPC.c PipeStream_LPC.h USBController_LPC.c USBController_LPC.h
  group src/usb_task/nxpUsbLib/Drivers/Core/LPC/DCD
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/LPC/DCD/LPC17XX/: Device_LPC17xx.h Endpoint_LPC17xx.c Endpoint_LPC17xx.h
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/LPC/DCD/: EndpointCommon.h
  group src/usb_task/nxpUsbLib/Drivers/Core/LPC/HAL
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/LPC/HAL/: HAL_LPC.h
    src/src/usb_task/nxpUSBLib/Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c HAL_LPC17xx.h
  group ucos-III
    src/uCOS-III/: includes.h
  group ucos-III/Ports
    src/uCOS-III/Ports/ARM-Cortex-M3/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group ucos-III/Source
    src/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
  group ucos-III/uc-Cpu
    src/uCOS-III/uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_c.c
    src/uCOS-III/uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group ucos-III/uc-Lib
    src/uCOS-III/uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
    src/uCOS-III/uC-LIB/Ports/ARM-Cortex-M3/: lib_mem_a.asm
  group utils
    src/utils/: utils_srv.c utils_srv.h
